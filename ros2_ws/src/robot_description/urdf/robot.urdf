Commit message: Milestone 1: Setup ROS2 workspace and robot packages

File: ros2_ws/src/robot_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot rl_robot, 1 links, 0 joints
Links:
- link base_link: mass 5.0 -> 5
